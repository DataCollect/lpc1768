# Keil uVision project YG825G.uvproj, settings and files
target LPC1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LPC1700 +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\LPC1768\Drivers\include;..\LPC1768\Core\CoreSupport;..\LPC1768\Core\DeviceSupport\NXP\LPC17xx;..\user_out;..\user_in;..\user\app;..\uC-CPU\ARM-Cortex-M3\RealView;..\uC-CPU\Cfg\Template;..\uC-CPU;..\uC-CPU\ARM-Cortex-M3;..\uCOS-III\Ports;..\uC-CPU\Cfg;..\uC-LIB\Cfg\Template;..\uC-LIB;..\uCOS-III\Source;..\uCOS-III\cfg;..\uCOS-III\Ports;..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group LPC1700_Startup
    ../LPC1768/Core/DeviceSupport/NXP/LPC17xx/startup/: startup_LPC17xx.s
    ../LPC1768/Core/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
  group LPC1700_drivers
    ../LPC1768/Drivers/source/: lpc17xx_clkpwr.c lpc17xx_pinsel.c lpc7xx_gpio.c lpc17xx_uart.c lpc17xx_timer.c lpc17xx_systick.c lpc17xx_adc.c lpc17xx_rtc.c lpc17xx_pwm.c lpc17xx_dac.c lpc17xx_i2c.c
    ../LPC1768/Drivers/include/: lpc17xx_cfg.h
  group bsp
    ../BSP/: bsp.c
  group user
    ../user/app/: main.c user_system_init.c ts_serv.c ts_serv.h sensor_test.h ts_serv_ex.c ts_serv_ex.h
    ../uCOS-III/cfg/: os_app_hooks.c
  group vir
    ../BSP/: vir.c serial.c serial.h
  group ucos_kernel
    ../uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group ucos_ports
    ../uCOS-III/Ports/: os_cpu_c.c os_cpu_a.s
  group uc_cpu
    ../uC-CPU/: cpu_core.c cpu_c.c cpu_a.s
  group uc_lib
    ../uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_mem_a.asm lib_cfg.h
